# IAR project Backup (5) of demo.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: port; hal; task; osal; ; STM8S_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.hex
  ILINK.IlinkOutputFile: demo.hex
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group hal
    hal/: hal_flash.c hal_init.c hal_pushrod.c hal_timer.c hal_uart.c
  group port
    port/: port_flash.c port_pushrod.c
  group StdPeriph_Driver
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_flash.c stm8s_gpio.c stm8s_tim4.c stm8s_uart1.c
  group task
    task/: app_task.c memory_task.c pushrod_task.c TimeOut.c
  group user
    ./: main.c stm8s_conf.h
    STM8S_StdPeriph_Driver/inc/: stm8s.h
