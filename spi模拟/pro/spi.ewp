# IAR project spi.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; USE_STDPERIPH_DRIVER; spi_slave
  ICCSTM8.CCIncludePath2: C:\Users\Administrator\Desktop\spi_string\spi模拟\24L01; C:\Users\Administrator\Desktop\spi_string\spi模拟\bsp; C:\Users\Administrator\Desktop\spi_string\spi模拟\lib\inc; C:\Users\Administrator\Desktop\spi_string\spi模拟\TimeOut; C:\Users\Administrator\Desktop\spi_string\spi模拟\user
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: spi.srec
  ILINK.IlinkOutputFile: spi.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group bsp
    ../bsp/: bsp_led.c bsp_timer.c
    ../24L01/: hal_spi.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim4.c stm8s_uart1.c
  group TimeOut
    ../TimeOut/: TimeOut.c
  group user
    ../user/: main.c stm8s_it.c system.c
