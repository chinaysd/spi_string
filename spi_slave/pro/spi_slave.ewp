# IAR project spi_slave.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103; USE_STDPERIPH_DRIVER
  ICCSTM8.CCIncludePath2: C:\Users\Administrator\Desktop\spi_slave\bsp; C:\Users\Administrator\Desktop\spi_slave\lib\inc; C:\Users\Administrator\Desktop\spi_slave\TimeOut; C:\Users\Administrator\Desktop\spi_slave\user
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: spi_slave.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group bsp
    ../bsp/: bsp_led.c bsp_spi.c
  group lib
    ../lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_iwdg.c stm8s_spi.c stm8s_tim4.c stm8s_uart1.c
  group user
    ../user/: main.c stm8s_it.c system.c
